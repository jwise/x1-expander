File: 3_GPIO.kicad_sch (KiCad schematic)
At the start: 17 parts, among them P3 A_A4

Commit message: initial full placement and routing
Connections:
- net ACBUS0: now also D2.3; no longer D2.1
- net ACBUS1: now also D2.1; no longer D2.3
- net ACBUS4: now also D3.3; no longer D3.1
- net ACBUS5: now also D3.1; no longer D3.3
- net ADBUS0: now also D4.3; no longer D4.1
- net ADBUS1: now also D4.1; no longer D4.3
- net ADBUS4: now also D5.3; no longer D5.1
- net ADBUS5: now also D5.1; no longer D5.3
- net BCBUS0: now also D6.3; no longer D6.1
- net BCBUS1: now also D6.1; no longer D6.3
- net BCBUS4: now also D7.3; no longer D7.1
- net BCBUS5: now also D7.1; no longer D7.3
- net BDBUS0: now also D8.3; no longer D8.1
- net BDBUS1: now also D8.1; no longer D8.3
- net BDBUS4: now also D9.3; no longer D9.1
- net BDBUS5: now also D9.1; no longer D9.3

Commit message: clean up DRC and silkscreen
Parts:
- R18: value 10kΩ -> 330
Changed lines of the file:
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@@
 			)
 		)
-		(property "Value" "10kΩ"
+		(property "Value" "330"
 			(at 235.204 164.7698 90)
 			(effects

Commit message: add LCSC part tags, silkscreen
Parts:
- ACBUS1, ADBUS1, BCBUS1, BDBUS1: LCSC (none) -> C5372877
- D2, D3, D4, D5, D6, D7, D8, D9: LCSC (none) -> C2687126
- R18: LCSC (none) -> C23138
- R19, R20: LCSC (none) -> C23162
Changed lines of the file:
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@@
+			)
+		)
+		(property "LCSC" "C5372877"
+			(at 186.436 117.9322 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
 			)
 		)
@@
 			)
 		)
+		(property "LCSC" "C2687126"
+			(at 46.99 65.1256 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			)
 		)
+		(property "LCSC" "C5372877"
+			(at 186.436 59.5122 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "9"
 		)
@@
 			)
 		)
+		(property "LCSC" "C2687126"
+			(at 120.65 65.1256 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			)
 		)
+		(property "LCSC" "C5372877"
+			(at 186.436 88.7222 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "6"
 		)
@@
 			)
 		)
+		(property "LCSC" "C2687126"
+			(at 46.99 109.5756 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			)
 		)
+		(property "LCSC" "C2687126"
+			(at 120.65 109.5756 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "3"
 		)
@@
 			)
 		)
+		(property "LCSC" "C2687126"
+			(at 46.99 150.2156 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			)
 		)
+		(property "LCSC" "C2687126"
+			(at 120.65 150.2156 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "3"
 		)
@@
 			)
 		)
+		(property "LCSC" "C2687126"
+			(at 120.65 24.4856 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "2"
 		)
@@
 			)
 		)
+		(property "LCSC" "C23162"
+			(at 239.014 152.3238 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			)
 		)
+		(property "LCSC" "C23138"
+			(at 235.204 162.4838 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			)
 		)
+		(property "LCSC" "C23162"
+			(at 245.364 165.0238 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			)
 		)
+		(property "LCSC" "C5372877"
+			(at 186.436 30.3022 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "4"
 		)
@@
 				(hide yes)
 			)
+		)
+		(property "LCSC" "C2687126"
+			(at 46.99 24.4856 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)

Commit message: LCSC part updates
Parts:
- I2C1: renamed from STEMMA-I2C1; LCSC (none) -> C160235
Changed lines of the file:
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@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "STEMMA-I2C1"
+		(property "Reference" "I2C1"
 			(at 258.1148 149.7838 0)
 			(effects
@@
 			)
 		)
+		(property "LCSC" "C160235"
+			(at 258.1148 149.7838 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
 		(pin "1"
 		)
@@
 			(project "ProProject_X1 Expander_2024-05-26_15-16-51_2024-05-26"
 				(path "/5c4052f8-31d6-4de3-b862-4d09b0660e26/52713671-aa4b-4412-b159-5876c2aaf3b7"
-					(reference "STEMMA-I2C1")
+					(reference "I2C1")
 					(unit 1)
 				)
